# Keil uVision project USBD_HID_Keyboard.uvproj, settings and files
target USBD_HID_Keyboard (6190000::V6.19::ARMCLANG)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: USBD_HID_Keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: CFG_TUD_ENABLED, CFG_TUSB_MCU = OPT_MCU_M031, TU_BYTE_ORDER = TU_LITTLE_ENDIAN,
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\tinyusb-master\src;..\..\..\..\ThirdParty\tinyusb-master\examples\device\hid_multiple_interface\src;..\..\..\..\ThirdParty\tinyusb-master\src\common;..\..\..\..\ThirdParty\tinyusb-master\hw;..\..\..\..\ThirdParty\tinyusb-master\src\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c
    ../../../../ThirdParty/tinyusb-master/src/portable/nuvoton/M031/: dcd_M031.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c gpio.c
  group tinyusb
    ../../../../ThirdParty/tinyusb-master/src/device/: usbd.c usbd_control.c
    ../../../../ThirdParty/tinyusb-master/src/: tusb.c
    ../../../../ThirdParty/tinyusb-master/src/common/: tusb_fifo.c
    ../../../../ThirdParty/tinyusb-master/src/class/hid/: hid_device.c
    ../../../../ThirdParty/tinyusb-master/examples/device/hid_multiple_interface/src/: usb_descriptors.c
